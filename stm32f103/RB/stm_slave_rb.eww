<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm_slave_rb.ewp</path>
    </project>
    <batchBuild />
</workspace>
